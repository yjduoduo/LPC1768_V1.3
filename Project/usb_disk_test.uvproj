# Keil uVision project usb_disk_test.uvproj, settings and files
target usb_disk_test (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 139W +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o./output/139W.bin ./output/139W.axf
  c flags: Optim=1
  c include: ..\inc;..\src;..\src\APP;..\src\Hardware\CSSP;..\src\Hardware;..\src\Board;..\src\Share;..\src\Hardware\I2C;..\src\Hardware\Timer;..\src\Hardware\GPIO;..\src\Hardware\UART;..\src\10Task;..\src\20RunCtrl;..\src\Hardware\Extint;..\src\11DisMenu;..\src\12UARTHandle;..\src\13CirCon;..\src\14Sand195
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ../src/: startup_LPC17xx.s
  group Source Group
    ../src/: core_cm3.c system_LPC17xx.c
  group APP
    ../src/APP/: main.c main.h Config.h include.h
  group HardWare
    ../src/Hardware/CSSP/: ssp.c ssp.h
    ../src/Hardware/: Delay.c Delay.h PWM.c PWM.h
    ../src/Hardware/I2C/: i2c.c i2c.h
    ../src/Hardware/UART/: uart.c uart.h
    ../src/Hardware/GPIO/: GPIOInit.C GPIOInit.h
    ../src/Hardware/Extint/: extint.c extint.h
    ../src/Hardware/Timer/: CTime.c CTime.h CTimeDef.c CTimeDef.h
  group Board
    ../src/Board/: lcd.c lcd.h pcf8563.c pcf8563.h key.c key.h CLED.c CLED.h CRelay.c CRelay.h
  group Share
    ../src/Share/: buffer.c buffer.h ziku.h CGrapParam.c CGrapParam.h CSetCurrent.c CSetCurrent.h CFlashParam.c CFlashParam.h CSendToFlash.c CSendToFlash.h CMaDefine.h CGetCompSum.c CGetCompSum.h CSpeaker.c CSpeaker.h CIntStEnd.c CIntStEnd.h HZK16F.h
  group 10 Task
    ../src/10Task/: initialization.c initialization.h
  group 11 DisMenu
    ../src/11DisMenu/: alarmenu.c alarmenu.h batteryLow.c batteryLow.h breakdown.c breakdown.h checkmenu.c checkmenu.h mainmenu.c mainmenu.h setmenu.c setmenu.h startmenu.c startmenu.h testmenu.c testmenu.h CLocalSet.c CLocalSet.h CCompReg.c CCompReg.h CCompSet.c CCompSet.h CDateMod.c CDateMod.h CAnnotate.c CAnnotate.h CCompStat.c CCompStat.h CSysCheck.c CSysCheck.h CCompInten.c CCompInten.h CHistoryList.c CHistoryList.h CTestSelf.c CTestSelf.h CModelFault.c CModelFault.h CSysReset.c CSysReset.h
  group 12 UartHandle
    ../src/12UARTHandle/: CComHandle.c CComHandle.h CComPara.c CComPara.h CComAnn.c CComAnn.h
  group 13 CircuitCon
    ../src/13CirCon/: CAddressCount.c CAddressCount.h
  group 14 Send195
    ../src/14Sand195/: CSendTo195.c CSendTo195.h
  group 20 RunCtrl
    ../src/20RunCtrl/: runfunction.c runfunction.h tasklist.c tasklist.h CTaskSure.c CTaskSure.h CGetGrap.c CGetGrap.h CTaskReturn.c CTaskReturn.h CKeyCounter.c CKeyCounter.h CTaskDown.c CTaskDown.h CTaskUp.c CTaskUp.h
